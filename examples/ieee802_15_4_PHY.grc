options:
  parameters:
    author: semulate
    category: '[IEEE802.15.4]'
    generate_options: hb
    id: ieee802_15_4_PHY
    output_language: python
    title: IEEE802.15.4 PHY
  states: {}

blocks:
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth (Hz)
    type: intx
    value: '1'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center Freq (Hz)
    type: intx
    value: '1'
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debug
    type: intx
    value: '1'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '100'
    type: '0'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_phy_msg_handler_0
  id: ieee802_15_4_phy_msg_handler
  parameters:
    bw0: bandwidth
    center_freq0: center_freq
    debug: bool(debug)
    rxg: rx_gain
    samp_rate: samp_rate
    txg: tx_gain
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: sduout
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: rxout
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: txout
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: txctrl
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: rxctrl
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sduin
    optional: 'True'
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: rxin
    type: complex
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: 'RX Gain '
    type: intx
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: long
    value: '1'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX Gain
    type: intx
    value: '1'
  states: {}

connections:
- [digital_probe_mpsk_snr_est_c_0, signal, ieee802_15_4_phy_msg_handler_0, signal_strength]
- [ieee802_15_4_oqpsk_phy_0, '0', pad_sink_1, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_phy_msg_handler_0, phy_in]
- [ieee802_15_4_oqpsk_phy_0, rxout, pad_sink_0_0, in]
- [ieee802_15_4_phy_msg_handler_0, conf_out, pad_sink_0, in]
- [ieee802_15_4_phy_msg_handler_0, data_out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_phy_msg_handler_0, manag_rx_out, pad_sink_3, in]
- [ieee802_15_4_phy_msg_handler_0, manag_tx_out, pad_sink_2, in]
- [pad_source_0, out, ieee802_15_4_phy_msg_handler_0, tcp_in]
- [pad_source_1, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [pad_source_1, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1

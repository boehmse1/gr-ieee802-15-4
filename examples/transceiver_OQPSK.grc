options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: transceiver_OQPSK
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: frequency_26
  id: variable
  parameters:
    value: '2480000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: rx_gain_amp_rf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain_lna_if
  id: variable
  parameters:
    value: '42'
  states: {}
- name: rx_gain_vga_bb
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: tx_gain_amp_rf
  id: variable
  parameters:
    value: '14'
  states: {}
- name: tx_gain_vga_bb
  id: variable
  parameters:
    value: '12'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/semulate/tmp/test.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello World!\n")
    period: '1000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '100000'
    type: '0'
  states: {state: disabled}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'True'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '1000'
    pad_tail: '1000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: note_0
  id: note
  parameters:
    note: This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    ant0: TX
    args: '"hackrf=0"'
    bb_gain0: rx_gain_vga_bb
    bw0: bandwidth
    freq0: frequency_26
    gain0: rx_gain_amp_rf
    if_gain0: rx_gain_lna_if
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX
    args: '"hackrf=0"'
    bb_gain0: rx_gain_vga_bb
    bw0: bandwidth
    freq0: frequency_26
    gain0: rx_gain_amp_rf
    gain_mode0: 'False'
    if_gain0: rx_gain_lna_if
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: frequency_26
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: bandwidth
    fc: frequency_26
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency_26
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [blocks_null_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [blocks_socket_pdu_0_0, pdus, ieee802_15_4_rime_stack_0, bcin]
- [digital_probe_mpsk_snr_est_c_0, signal, blocks_message_debug_0, print]
- [foo_packet_pad2_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', osmosdr_sink_0_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', qtgui_freq_sink_x_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, blocks_message_debug_0, print]
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, bcout, blocks_socket_pdu_0_0, pdus]
- [ieee802_15_4_rime_stack_0, toMAC, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [osmosdr_source_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [osmosdr_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

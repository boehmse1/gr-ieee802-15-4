options:
  parameters:
    author: semulate
    category: '[IEEE802.15.4]'
    generate_options: qt_gui
    id: transceiver_PCAPNG_OQPSK
    output_language: python
    title: IEEE 802.15.4 Transceiver using OQPSK PHY and PCAPNG Connection
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '2480000000'
  states: {}
- name: frequency_0
  id: variable
  parameters:
    value: 2405e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: PHY_SDU_interpreter_0
  id: PHY_SDU_interpreter
  parameters:
    parameter_0: '1'
    parameter_2: '1'
    parameter_3: '1'
    parameter_4: '1'
    parameter_4_0: '0'
    parameter_s: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.pcapng
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '512'
    port: '4242'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '147'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_phy_msg_handler_0
  id: ieee802_15_4_phy_msg_handler
  parameters:
    bw0: '0'
    center_freq0: '0'
    debug: 'False'
    rxg: '0'
    samp_rate: '0'
    txg: '0'
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: pcapng_connector_0
  id: pcapng_connector
  parameters: {}
  states: {}

connections:
- [PHY_SDU_interpreter_0, conf_out, pcapng_connector_0, PDUin]
- [PHY_SDU_interpreter_0, data_out, ieee802_15_4_oqpsk_phy_0, txin]
- [PHY_SDU_interpreter_0, manag_rx_out, blocks_message_debug_0, print]
- [PHY_SDU_interpreter_0, manag_tx_out, blocks_message_debug_0, print]
- [analog_sig_source_x_0, '0', PHY_SDU_interpreter_0, '0']
- [analog_sig_source_x_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [blocks_socket_pdu_0_0, pdus, pcapng_connector_0, TCPin]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, PHY_SDU_interpreter_0, phy_in]
- [pcapng_connector_0, PDUout, PHY_SDU_interpreter_0, tcp_in]
- [pcapng_connector_0, PDUout, foo_wireshark_connector_0, in]
- [pcapng_connector_0, TCPout, blocks_socket_pdu_0_0, pdus]

metadata:
  file_format: 1

options:
  parameters:
    author: semulate
    category: '[IEEE802.15.4]'
    generate_options: qt_gui
    id: transceiver_OQPSK_PCAPNG
    output_language: python
    title: IEEE 802.15.4 Transceiver using OQPSK PHY and PCAPNG Connection
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2405e6
  states: {}
- name: frequency_26
  id: variable
  parameters:
    value: '2480000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: rx_gain_amp
  id: variable
  parameters:
    value: '14'
  states: {}
- name: rx_gain_lna
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rx_gain_vga
  id: variable
  parameters:
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.pcapng
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '512'
    port: '4242'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: ieee802_15_4_PHY_0
  id: ieee802_15_4_PHY
  parameters:
    bandwidth: bandwidth
    center_freq: frequency_26
    debug: '1'
    rx_gain: rx_gain
    samp_rate: samp_rate
    tx_gain: tx_gain
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: pcapng_connector_0
  id: pcapng_connector
  parameters: {}
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidth
    fc: frequency_26
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    amp_gain0: rx_gain_amp
    ant0: TX/RX
    args: '"hackrf=0"'
    balance0: '0'
    bw0: bandwidth
    center_freq0: frequency_26
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: hackrf
    gain_mode0: Specific
    lna_gain0: rx_gain_lna
    samp_rate: samp_rate
    type: fc32
    vga_gain0: rx_gain_vga
  states: {}

connections:
- [blocks_socket_pdu_0_0, pdus, pcapng_connector_0, TCPin]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_15_4_PHY_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_PHY_0, sduout, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_PHY_0, sduout, foo_wireshark_connector_0, in]
- [ieee802_15_4_PHY_0, sduout, pcapng_connector_0, PDUin]
- [ieee802_15_4_PHY_0, txctrl, soapy_source_0, command]
- [pcapng_connector_0, PDUout, foo_wireshark_connector_0, in]
- [pcapng_connector_0, PDUout, ieee802_15_4_PHY_0, sduin]
- [pcapng_connector_0, TCPout, blocks_socket_pdu_0_0, pdus]
- [qtgui_waterfall_sink_x_0, freq, blocks_message_debug_0, print]
- [soapy_source_0, '0', ieee802_15_4_PHY_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

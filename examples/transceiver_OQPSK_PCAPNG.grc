options:
  parameters:
    author: semulate
    category: '[IEEE802.15.4]'
    generate_options: qt_gui
    id: transceiver_OQPSK_PCAPNG
    output_language: python
    title: IEEE 802.15.4 Transceiver using OQPSK PHY and PCAPNG Connection
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2405e6
  states: {}
- name: frequency_26
  id: variable
  parameters:
    value: '2480000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: rx_gain_amp_rf
  id: variable
  parameters:
    value: '14'
  states: {}
- name: rx_gain_lna_if
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rx_gain_vga_bb
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: tx_gain_amp_rf
  id: variable
  parameters:
    value: '14'
  states: {}
- name: tx_gain_vga_if
  id: variable
  parameters:
    value: '24'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '512'
    port: '4244'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {}
- name: foo_pad_tagged_stream_0
  id: foo_pad_tagged_stream
  parameters:
    buffer_size: '0x4200'
    len_tag_name: packet_len
  states: {state: disabled}
- name: ieee802_15_4_PHY_0
  id: ieee802_15_4_PHY
  parameters:
    bandwidth: bandwidth
    center_freq: frequency_26
    debug: '1'
    rx_gain: rx_gain
    samp_rate: samp_rate
    tx_gain: tx_gain
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX
    args: buffers=1
    bb_gain0: '24'
    bw0: bandwidth
    freq0: frequency_26
    gain0: tx_gain_amp_rf
    if_gain0: tx_gain_vga_if
    maxoutbuf: '8192'
    minoutbuf: '8192'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX
    args: soapy=0,driver=hackrf
    bb_gain0: rx_gain_vga_bb
    bw0: bandwidth
    freq0: frequency_26
    gain0: rx_gain_amp_rf
    gain_mode0: 'False'
    if_gain0: rx_gain_lna_if
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pcapng_connector_0
  id: pcapng_connector
  parameters:
    debug: '1'
    file: /tmp/capture.pcap
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    amp_gain0: tx_gain_amp_rf
    args: hackrf=0
    bw0: bandwidth
    center_freq0: frequency_26
    devname: hackrf
    samp_rate: samp_rate
    type: fc32
    vga_gain0: tx_gain_vga_if
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    amp_gain0: rx_gain_amp_rf
    ant0: TX/RX
    args: '"hackrf=0"'
    balance0: '0'
    bw0: bandwidth
    center_freq0: frequency_26
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: hackrf
    gain_mode0: Specific
    lna_gain0: rx_gain_lna_if
    samp_rate: samp_rate
    type: fc32
    vga_gain0: rx_gain_vga_bb
  states: {state: disabled}

connections:
- [blocks_null_source_0, '0', ieee802_15_4_PHY_0, '0']
- [blocks_socket_pdu_0_0, pdus, pcapng_connector_0, TCPin]
- [foo_pad_tagged_stream_0, '0', osmosdr_sink_0, '0']
- [foo_pad_tagged_stream_0, '0', soapy_sink_0, '0']
- [ieee802_15_4_PHY_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_PHY_0, '0', foo_pad_tagged_stream_0, '0']
- [ieee802_15_4_PHY_0, '0', soapy_sink_0, '0']
- [ieee802_15_4_PHY_0, rxctrl, blocks_message_debug_0, print]
- [ieee802_15_4_PHY_0, rxctrl, osmosdr_source_0, command]
- [ieee802_15_4_PHY_0, rxctrl, soapy_sink_0, command]
- [ieee802_15_4_PHY_0, sduout, pcapng_connector_0, PDUin]
- [ieee802_15_4_PHY_0, txctrl, blocks_message_debug_0, print]
- [ieee802_15_4_PHY_0, txctrl, soapy_source_0, command]
- [osmosdr_source_0, '0', ieee802_15_4_PHY_0, '0']
- [pcapng_connector_0, PDUout, ieee802_15_4_PHY_0, sduin]
- [pcapng_connector_0, TCPout, blocks_socket_pdu_0_0, pdus]
- [soapy_source_0, '0', ieee802_15_4_PHY_0, '0']

metadata:
  file_format: 1

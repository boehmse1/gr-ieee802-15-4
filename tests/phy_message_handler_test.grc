options:
  parameters:
    author: semulate
    generate_options: qt_gui
    id: phy_message_handler_test
    output_language: python
    title: IEEE802.15.4 PHY Message Handler Module Test
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2405e6
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '2480000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '100'
    type: '0'
  states: {}
- name: ieee802_15_4_phy_msg_handler_0
  id: ieee802_15_4_phy_msg_handler
  parameters:
    bw0: bandwidth
    center_freq0: frequency
    debug: 'False'
    rxg: rx_gain
    samp_rate: samp_rate
    txg: tx_gain
  states: {}

connections:
- [analog_noise_source_x_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [blocks_message_strobe_0, strobe, ieee802_15_4_phy_msg_handler_0, phy_in]
- [blocks_message_strobe_0, strobe, ieee802_15_4_phy_msg_handler_0, tcp_in]
- [digital_probe_mpsk_snr_est_c_0, signal, ieee802_15_4_phy_msg_handler_0, signal_strength]

metadata:
  file_format: 1
